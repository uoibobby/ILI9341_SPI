# Keil uVision project QDtech_TFT.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32-FD-FLASHLED +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\FWlib\inc;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group ASM
    ./startup/: startup_stm32f10x_hd.s
  group USR
    ./user/: stm32f10x_it.c main.c Lcd_Driver.c delay.c GUI.c QDTFT_demo.c led.c
  group FWlib
    ./FWlib/SRC/: stm32f10x_gpio.c misc.c stm32f10x_rcc.c stm32f10x_spi.c
  group CMSYS
    ./user/: core_cm3.c system_stm32f10x.c
software components: CMSIS:CORE 5.1.1
